# IAR project HEXIWEAR_bluetooth.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../../app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK_1_3_0_PATH_$/platform/CMSIS/Include; ../../../../../../../boards/frdmkw40z; $_KSDK_1_3_0_PATH_$/platform/devices; $_KSDK_1_3_0_PATH_$/platform/devices/MKW40Z4/include; $_KSDK_1_3_0_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK_1_3_0_PATH_$/platform/system/src/clock/MKW40Z4; $_KSDK_1_3_0_PATH_$/platform/devices; $_KSDK_1_3_0_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK_1_3_0_PATH_$/rtos/FreeRTOS/include; $_KSDK_1_3_0_PATH_$/rtos/FreeRTOS/port/iar; $_KSDK_1_3_0_PATH_$/rtos/FreeRTOS/config/KW40Z4/iar; ../../../../../../../framework/Flash/External/Interface; ../../../../../../../framework/Flash/External/Interface/Eeprom_M25P80; ../../../../../../../framework/Flash/Internal; ../../../../../../../framework/SerialManager/Source/SPI_Adapter; $_KSDK_1_3_0_PATH_$/platform/drivers/src/flash/C90TFS/drvsrc/include; ../../../../../../../framework/GPIOIrq; ../../../../../../../framework/Keyboard/Interface; ../../../../../../../framework/LED/Interface; ../../../../../../../framework/Common; ../../../../../../../framework/MemManager/Interface; ../../../../../../../framework/Messaging/Interface; ../../../../../../../framework/LowPower/Interface/MKW4xZ; ../../../../../../../framework/LowPower/Interface/MKW4xZ; ../../../../../../../framework/OSAbstraction/Interface; $_KSDK_1_3_0_PATH_$/platform/osa/inc; ../../../../../../../framework/OtaSupport/Interface; ../../../../../../../framework/Panic/Interface; ../../../../../../../framework/RNG/Interface; ../../../../../../../framework/SerialManager/Interface; ../../../../../../../framework/TimersManager/Interface; ../../../../../../../framework/TimersManager/Source; ../../../../../../../framework/FunctionLib; ../../../../../../../framework/Lists; ../../../../../../../framework/SecLib; ../../../../../../../framework/ModuleInfo; ../../../../../../../bluetooth/host/interface; ../../../../../common; ../../../../../common; ../../../../../../../bluetooth/controller/interface; ../../../../../common; ../../../../../../../bluetooth/hci_transport/interface; ../../../../../common/gatt_db; ../../../../../common/gatt_db/macros; ../../../../../../../bluetooth/profiles/battery; ../../../../../../../bluetooth/profiles/device_info; ../../../../../../../framework/XCVR/MKW40Z4; ../../../../common; ../../../../../../../framework/DCDC/Interface; ../../../../common/TSI; ../../../../common/Host MCU Interface; ../../../../common/Client ANCS; ../../../../common/Server Services; ../../../../common/ft/include; $_KSDK_1_3_0_PATH_$/platform/drivers/inc; $_KSDK_1_3_0_PATH_$/platform/system/inc; $_KSDK_1_3_0_PATH_$/platform/hal/inc; $_KSDK_1_3_0_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: $_KSDK_PATH_$\rtos\FreeRTOS\config\KW40Z4\iar
  OBJCOPY.OOCOutputFile: HEXIWEAR_bluetooth.bin
  ILINK.IlinkOutputFile: HEXIWEAR_bluetooth_FreeRTOS.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0; __stack_size__=384; gUseBootloaderLink_d=1; gUseInternalStorageLink_d=0; __ram_vector_table__=1; gNVMSectorCountLink_d=1
  ILINK.IlinkIcfFile: ../../../../../../../platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../bluetooth/host/lib/ble_host_lib.a; $_KSDK_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\debug\libksdk_platform_freertos.a; ../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a; ../../../../../../../bluetooth/controller/lib/ble_controller_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCIncludePath2: $_KSDK_PATH_$/platform/CMSIS/Include; ../../../../../../../boards/frdmkw40z; $_KSDK_PATH_$/platform/devices; $_KSDK_PATH_$/platform/devices/MKW40Z4/include; $_KSDK_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK_PATH_$/platform/system/src/clock/MKW40Z4; $_KSDK_PATH_$/platform/devices; $_KSDK_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK_PATH_$/rtos/FreeRTOS/include; $_KSDK_PATH_$/rtos/FreeRTOS/port/iar; $_KSDK_PATH_$/rtos/FreeRTOS/config/KW40Z4/iar; ../../../../../../../drv/Portable/Flash_Adapter; $_KSDK_PATH_$/platform/drivers/src/flash/C90TFS/drvsrc/include; ../../../../../../../drv/Portable/GPIO_IrqAdapter; ../../../../../../../drv/Portable/Keyboard/Interface; ../../../../../../../drv/Portable/LED/Interface; ../../../../../../../drv/Portable/TMR_Adapter; ../../../../../../../framework/Common; ../../../../../../../framework/MemManager/Interface; ../../../../../../../framework/Messaging/Interface; ../../../../../../../framework/OSAbstraction/Interface; $_KSDK_PATH_$/platform/osa/inc; ../../../../../../../framework/Panic/Interface; ../../../../../../../framework/RNG/Interface; ../../../../../../../framework/SerialManager/Interface; ../../../../../../../framework/TimersManager/Interface; ../../../../../../../framework/Utils/FunctionLib; ../../../../../../../framework/Utils/Lists; ../../../../../../../framework/Utils/SecLib; ../../../../../../../framework/Utils/ModuleInfo; ../../../../../../../bluetooth/host/interface; ../../../../../common; ../../../../../common; ../../../../../../../bluetooth/controller/interface; ../../../../../common; ../../../../../../../bluetooth/hci_transport/interface; ../../../../../common/gatt_db; ../../../../../common/gatt_db/macros; ../../../../../../../bluetooth/profiles/interface; ../../../../../../../bluetooth/profiles/interface; ../../../../../../../bluetooth/profiles/interface; ../../../../../../../drv/KW40Z/XCVR/Interface; ../../../../common; $_KSDK_PATH_$/platform/drivers/inc; $_KSDK_PATH_$/platform/system/inc; $_KSDK_PATH_$/platform/hal/inc; $_KSDK_PATH_$/platform/utilities/inc
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: heart_rate_sensor_FreeRTOS.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0; __stack_size__=384; __ram_vector_table__=1
  ILINK.IlinkAdditionalLibs: ../../../../../../../bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\release\libksdk_platform_freertos.a; ../../../../../../../framework/Utils/SecLib/lib_crypto_IAR_M0.a; ../../../../../../../bluetooth/controller/lib/ble_controller_lib.a
  group app/common
    ../../../../../common/: ApplMain.c ApplMain.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h
  group app/common/gatt_db
    ../../../../../common/gatt_db/: gatt_database.c gatt_db_handles.h
  group app/common/gatt_db/macros
    ../../../../../common/gatt_db/macros/: gatt_alloc_x.def gatt_db_macros.h gatt_db_x_macros.def gatt_decl_x.def gatt_enum_x.def gatt_init_x.def gatt_size_x.def gatt_uuid_decl_x.def gatt_uuid_def_x.def
  group app/HEXIWEAR_bluetooth
    ../../../../common/: app.c app.h app_config.c debug.h gatt_db.h gatt_uuid128.h
    ../../: app_preinclude.h
  group app/HEXIWEAR_bluetooth/Client ANCS/Interface
    ../../../../common/Client ANCS/: client_ancs.h
  group app/HEXIWEAR_bluetooth/Client ANCS/Source
    ../../../../common/Client ANCS/: client_ancs.c
  group app/HEXIWEAR_bluetooth/ft/include
    ../../../../common/ft/include/: ft.h ft_control_arotary.h ft_control_aslider.h ft_control_keypad.h ft_control_matrix.h ft_control_rotary.h ft_control_slider.h ft_controls.h ft_electrodes.h ft_filters.h ft_gpio.h ft_keydetector_afid.h ft_keydetector_safa.h ft_keydetectors.h ft_module_gpio.h ft_module_gpioint.h ft_module_tsi.h ft_modules.h ft_setup.h ft_system.h ft_types.h
  group app/HEXIWEAR_bluetooth/ft/source
    ../../../../common/ft/source/: ft.c ft_setup.c
  group app/HEXIWEAR_bluetooth/ft/source/controls
    ../../../../common/ft/source/controls/: ft_control_arotary.c ft_control_arotary_prv.h ft_control_aslider.c ft_control_aslider_prv.h ft_control_keypad.c ft_control_keypad_prv.h ft_control_matrix.c ft_control_rotary.c ft_control_rotary_prv.h ft_control_slider.c ft_control_slider_prv.h ft_controls.c ft_controls_prv.h
  group app/HEXIWEAR_bluetooth/ft/source/electrodes
    ../../../../common/ft/source/electrodes/: ft_electrodes.c ft_electrodes_prv.h
  group app/HEXIWEAR_bluetooth/ft/source/filters
    ../../../../common/ft/source/filters/: ft_filters.c ft_filters_prv.h
  group app/HEXIWEAR_bluetooth/ft/source/keydetectors
    ../../../../common/ft/source/keydetectors/: ft_keydetector_afid.c ft_keydetector_afid_prv.h ft_keydetector_prv.h ft_keydetector_safa.c ft_keydetector_safa_prv.h
  group app/HEXIWEAR_bluetooth/ft/source/modules
    ../../../../common/ft/source/modules/: ft_module_gpio.c ft_module_gpio_prv.h ft_module_gpioint.c ft_module_gpioint_prv.h ft_module_tsi.c ft_module_tsi_prv.h ft_modules.c ft_modules_prv.h
  group app/HEXIWEAR_bluetooth/ft/source/system
    ../../../../common/ft/source/system/: ft_system.c ft_system_frmstr.c ft_system_frmstr_prv.h ft_system_mem.c ft_system_mem_prv.h ft_system_prv.h
  group app/HEXIWEAR_bluetooth/Host MCU Interface/Interface
    ../../../../common/Host MCU Interface/: host_mcu_interface.h
  group app/HEXIWEAR_bluetooth/Host MCU Interface/Source
    ../../../../common/Host MCU Interface/: host_mcu_interface.c host_mcu_interface_events.c host_mcu_interface_rx.c host_mcu_interface_tx.c
  group app/HEXIWEAR_bluetooth/Server Services/Interface
    ../../../../common/Server Services/: alert_service.h appMode_service.h common_service.h health_service.h motion_service.h otap_interface.h weather_service.h
  group app/HEXIWEAR_bluetooth/Server Services/Source
    ../../../../common/Server Services/: alert_service.c appMode_service.c common_service.c health_service.c motion_service.c otap_service.c weather_service.c
  group app/HEXIWEAR_bluetooth/TSI/Interface
    ../../../../common/TSI/: tsi.h
  group app/HEXIWEAR_bluetooth/TSI/Source
    ../../../../common/TSI/: tsi.c
  group bluetooth/controller/interface
    ../../../../../../../bluetooth/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../bluetooth/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../bluetooth/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/interface
    ../../../../../../../bluetooth/host/interface/: att_errors.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h smp_packets.h smp_types.h vendor_debug_commands.h
  group bluetooth/host/source
    ../../../../../../../bluetooth/host/source/: ble_globals.c
  group bluetooth/profiles/battery
    ../../../../../../../bluetooth/profiles/battery/: battery_service.c
  group bluetooth/profiles/device_info
    ../../../../../../../bluetooth/profiles/device_info/: device_info_service.c
  group bluetooth/profiles/heart_rate
    ../../../../../../../bluetooth/profiles/heart_rate/: heart_rate_service.c
  group bluetooth/profiles/interface
    ../../../../../../../bluetooth/profiles/battery/: battery_interface.h
    ../../../../../../../bluetooth/profiles/device_info/: device_info_interface.h
    ../../../../../../../bluetooth/profiles/heart_rate/: heart_rate_interface.h
  group framework/Common
    ../../../../../../../framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/DCDC/Interface
    ../../../../../../../framework/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../framework/DCDC/Source/: DCDC.c
  group framework/Flash/External/Interface
    ../../../../../../../framework/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Sources
    ../../../../../../../framework/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c Eeprom_M25P80.c
  group framework/Flash/Internal
    ../../../../../../../../KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../../../framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
    ../../../../../../../../KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group framework/FunctionLib
    ../../../../../../../framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    ../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    ../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    ../../../../../../../framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../framework/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../framework/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../framework/Lists/: GenericList.c GenericList.h
  group framework/LowPower/Interface
    ../../../../../../../framework/LowPower/Interface/MKW4xZ/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../framework/LowPower/Source/MKW4xZ/: PWR.c PWR_BLE.c PWR_BLE.h PWRLib.c PWRLib.h
  group framework/MemManager/Interface
    ../../../../../../../framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    ../../../../../../../framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    ../../../../../../../framework/OSAbstraction/Source/: fsl_osa_ext_freertos.c
  group framework/OtaSupport/Interface
    ../../../../../../../framework/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../framework/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    ../../../../../../../framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../../../framework/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../framework/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../../../framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../../../framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/TimersManager/Interface
    ../../../../../../../framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW40Z4
    ../../../../../../../framework/XCVR/MKW40Z4/: BLEDefaults.h ifr_mkw40z4_radio.c ifr_mkw40z4_radio.h ifr_tbl_apache_radio.h KW4xXcvrDrv.c KW4xXcvrDrv.h overwrites.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group KSDK
    ../../../../../../../boards/frdmkw40z/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group RTOS/FreeRTOS
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/config/KW40Z4/iar/: FreeRTOSConfig.h
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
  group RTOS/FreeRTOS/Startup
    ../../../../../../../../KSDK_1.3.0/platform/devices/: startup.c startup.h
    ../../../../../../../../KSDK_1.3.0/platform/devices/MKW40Z4/startup/iar/: startup_MKW40Z4.s
    ../../../../../../../../KSDK_1.3.0/platform/devices/MKW40Z4/startup/: system_MKW40Z4.c system_MKW40Z4.h
